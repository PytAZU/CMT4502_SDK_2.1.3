# Keil uVision project aliGenie_mesh_fanlight.uvprojx, settings and files
target fanlight (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: aliGenie_mesh_fanlight +hex
  AfterMake: fromelf.exe --bin -o  ./aliGenie_mesh_fanlight.bin  ./Objects/aliGenie_mesh_fanlight.axf
  AfterMake: fromelf -c -a -d -e -v -o aliGenie_mesh_fanlight.asm ./Objects/aliGenie_mesh_fanlight.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP, OSAL_CBTIMER_NUM_TASKS=1, OSALMEM_METRICS=0 DEBUG_INFO=0 CFG_SLEEP_MODE = PWR_MODE_NO_SLEEP APP_CFG=0 ETHERMIND
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0x0c
  c include: ..\..\..\..\components\inc;..\..\..\..\components\ble\controller\include;..\..\..\..\components\osal\include;..\..\..\..\components\common;..\..\..\..\components\ble\include;..\..\..\..\components\ble\hci;..\..\..\..\components\ble\host;..\..\..\..\components\Profiles\DevInfo;..\..\..\..\components\Profiles\SimpleProfile;..\..\..\..\components\Profiles\Roles;..\..\..\..\components\driver\common;..\..\..\..\components\driver\clock;..\..\..\..\components\driver\gpio;..\..\..\..\components\driver\pwrmgr;..\..\..\..\components\driver\log;..\..\..\..\components\driver\uart;..\..\..\..\components\driver\flash;..\..\..\..\components\driver\pwm;..\..\..\..\components\ethermind\external\crypto\aes;..\..\..\..\components\ethermind\mesh\export\include;..\..\..\..\components\ethermind\mesh\export\bearer;..\..\..\..\components\ethermind\mesh\export\platforms\ext;..\..\..\..\components\ethermind\osal\src\phyos;..\..\..\..\components\ethermind\platforms\phy6200;..\..\..\..\components\ethermind\platforms\phy6200\mesh;..\..\..\..\components\ethermind\platforms\phy6200\interfaces\crypto;..\..\..\..\components\ethermind\platforms\phy6200\interfaces\nvs;..\..\..\..\components\ethermind\utils\include;..\..\..\..\components\ethermind\mesh\export\cli;..\..\..\..\components\ethermind\mesh\export\cli\model\client;..\..\..\..\components\ethermind\mesh\export\appl;..\..\..\..\components\driver\pwrmgr;..\..\..\..\components\osal\snv;..\..\..\..\components\ethermind\external\crypto\asm_ecdh_p256;..\..\..\..\components\ethermind\external\crypto\sha256;..\..\..\..\components\ethermind\lib;..\..\..\..\components\profiles\aliGenie;..\..\..\..\components\ethermind\mesh\export\cbtimer;.\source\include;..\..\..\..\components\ethermind\platforms\phy6200\mesh\aliGenie_bleMesh\include;..\..\..\..\components\ethermind\platforms\phy6200\mesh\aliGenie_bleMesh\libs;.\source;..\aliGenie_bleMesh\appl_base;..\aliGenie_bleMesh\include;..\aliGenie_bleMesh\libs;..\aliGenie_bleMesh\model_generic;..\..\..\..\components\ethermind\platforms;..\..\..\..\components\ethermind\platforms\interfaces\crypto;..\..\..\..\components\ethermind\platforms\mesh;..\..\..\..\components\libraries\cliface
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: --keep=jump_table_base  --keep=global_config ..\..\..\..\misc\rom1Sym.txt
  group arch
    ./source/: main.c
    ../../../../lib/: rf.lib
    ../../../../misc/: rom1Sym.txt
  group driver
    ../../../../components/driver/common/: common.c
    ../../../../components/driver/pwm/: pwm.c
    ../../../../components/driver/flash/: flash.c
    ../../../../components/driver/clock/: clock.c
    ../../../../components/driver/log/: my_printf.c
    ../../../../components/driver/gpio/: gpio.c
    ../../../../components/driver/uart/: uart.c
    ../../../../components/driver/pwrmgr/: pwrmgr.c
  group profile
    ../../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../../components/profiles/GATT/: gattservapp.c
    ../../../../components/profiles/Roles/: peripheral.c gapgattserver.c gap.c observer.c central.c gapbondmgr.c
    ../../../../components/profiles/Keys/: simplekeys.c
    ../../../../components/profiles/SimpleProfile/: simpleGATTprofile_ota.c
  group jump
    ./source/: jump_table.c
  group osal
    ../../../../components/osal/snv/: osal_snv.c
  group aliGenie_bleMesh
    ../../../../components/ethermind/external/crypto/sha256/: sha256.c
    ../../../../components/profiles/aliGenie/: ali_genie_profile.c
    ../aliGenie_bleMesh/appl_base/: aliGenie_appl_node_mng.c aliGenie_appl_Prov.c aliGenie_appl_Proxy.c aliGenie_blebrr.c aliGenie_bleMesh.c aliGenie_bleMesh_Main.c aliGenie_OSAL_bleMesh.c appl_utils.c
    ../aliGenie_bleMesh/model_generic/: aliGenie_appl_Generic_OnOff.c aliGenie_appl_Generic_Scene.c
    ../aliGenie_bleMesh/model_vendor/: aliGenie_appl_Vendor.c
    ../aliGenie_bleMesh/: aliGenie_appl_common.c
    ./source/model_vendor/: aliGenie_appl_Vendor_indications.c
    ../aliGenie_bleMesh/libs/: lib_light.c
    ../aliGenie_bleMesh/model_light/: aliGenie_appl_Light_Lightness.c aliGenie_appl_Light_HSL.c
  group ethermind
    ../../../../components/ethermind/external/crypto/aes/: aes.c aes-ccm.c
    ../../../../components/ethermind/osal/src/phyos/: EM_debug.c EM_os.c EM_timer.c
    ../../../../components/ethermind/mesh/export/bearer/: blebrr_gatt.c
    ../../../../components/ethermind/mesh/export/platforms/ext/: MS_common_pl.c prov_pl.c
    ../../../../components/ethermind/mesh/export/cbtimer/: EXT_cbtimer.c
    ../../../../components/ethermind/platforms/: EM_platform.c
    ../../../../components/ethermind/platforms/interfaces/crypto/: cry.c
    ../../../../components/ethermind/platforms/mesh/: mesh_clients.c mesh_services.c model_state_handler_pl.c blebrr_pl.c
  group mesh_lib
    ../../../../components/ethermind/lib/meshlibs/phyos/keil/: libethermind_mesh_core.lib libethermind_mesh_models.lib libethermind_utils.lib
  group aliGenie_bleMesh_appl
    ./source/appl_hard/: aliGenie_led_light.c
    ./source/model_vendor/: aliGenie_appl_Vendor_fan.c aliGenie_appl_Vendor_fanlight.c aliGenie_appl_Vendor_light.c
    ./source/: aliGenie_appl_fanlight.c
  group ecdh
    ../../../../components/ethermind/external/crypto/asm_ecdh_p256/: P256-cortex-m0-ecdh-keil.s
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
