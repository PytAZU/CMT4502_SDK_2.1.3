# Keil uVision project mesh_light.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: mesh_light +hex
  AfterMake: fromelf.exe --bin -o  ./mesh_light.bin  ./Objects/mesh_light.axf
  AfterMake: fromelf -c -a -d -e -v -o mesh_light.asm ./Objects/mesh_light.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP, OSAL_CBTIMER_NUM_TASKS=1, OSALMEM_METRICS=0 DEBUG_INFO=4 CFG_SLEEP_MODE = PWR_MODE_NO_SLEEP CFG_HEARTBEAT_MODE=0
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0x0c
  c include: ..\..\..\components\inc;..\..\..\components\ble\controller\include;..\..\..\components\osal\include;..\..\..\components\common;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\Profiles\DevInfo;..\..\..\components\Profiles\SimpleProfile;..\..\..\components\Profiles\Roles;..\..\..\components\driver\common;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\log;..\..\..\components\driver\uart;..\..\..\components\driver\flash;..\..\..\components\driver\pwm;.\source;.\source\bleMesh;..\..\..\components\ethermind\external\crypto\aes;..\..\..\components\ethermind\mesh\export\include;..\..\..\components\ethermind\mesh\export\bearer;..\..\..\components\ethermind\mesh\export\platforms\ext;..\..\..\components\ethermind\osal\src\phyos;..\..\..\components\ethermind\utils\include;..\..\..\components\ethermind\mesh\export\cli;..\..\..\components\ethermind\mesh\export\cli\model\client;..\..\..\components\ethermind\mesh\export\appl;..\..\..\components\driver\pwrmgr;..\..\..\components\osal\snv;..\..\..\components\ethermind\external\crypto\asm_ecdh_p256;..\..\..\components\ethermind\external\crypto\sha256;..\..\..\components\ethermind\lib;..\..\..\components\profiles\aliGenie;..\..\..\components\ethermind\mesh\export\cbtimer;..\..\..\components\profiles\ota_app;..\..\..\components\ethermind\platforms;..\..\..\components\ethermind\platforms\interfaces;..\..\..\components\ethermind\platforms\interfaces\crypto;..\..\..\components\ethermind\platforms\mesh;..\..\..\components\ethermind\mesh\export\vendormodel;..\..\..\components\ethermind\mesh\export\vendormodel\server;..\..\..\components\libraries\cliface
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: --keep=jump_table_base  --keep=global_config ..\..\..\misc\rom1Sym.txt
  group arch
    ./source/: main.c
    ../../../misc/: rom1Sym.txt
    ../../../lib/: rf.lib
  group driver
    ../../../components/driver/common/: common.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/libraries/cliface/: cliface.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/Roles/: peripheral.c gapgattserver.c gap.c observer.c central.c gapbondmgr.c
    ../../../components/profiles/ota_app/: ota_app_service.c
  group jump
    ./source/: jump_table.c
  group osal
    ../../../components/osal/snv/: osal_snv.c
  group blemesh
    ./source/bleMesh/: bleMesh.c bleMesh_Main.c OSAL_bleMesh.c led_light.c cli_vendor.c
    ../../../components/ethermind/external/crypto/sha256/: sha256.c
  group ethermind
    ../../../components/ethermind/platforms/: EM_platform.c
    ../../../components/ethermind/external/crypto/aes/: aes.c aes-ccm.c
    ../../../components/ethermind/osal/src/phyos/: EM_debug.c EM_os.c EM_timer.c
    ../../../components/ethermind/platforms/mesh/: blebrr_pl.c mesh_services.c model_state_handler_pl.c mesh_clients.c
    ../../../components/ethermind/mesh/export/bearer/: blebrr.c blebrr_gatt.c
    ../../../components/ethermind/platforms/interfaces/crypto/: cry.c
    ../../../components/ethermind/mesh/export/platforms/ext/: MS_common_pl.c prov_pl.c
    ../../../components/ethermind/mesh/export/appl/: appl_prov.c
    ../../../components/ethermind/mesh/export/cbtimer/: EXT_cbtimer.c
  group mesh_lib
    ../../../components/ethermind/lib/meshlibs/phyos/keil/: libethermind_mesh_core.lib libethermind_mesh_models.lib libethermind_utils.lib
  group samples
    ./source/bleMesh/: appl_sample_example_phylight.c
  group ecdh
    ../../../components/ethermind/external/crypto/asm_ecdh_p256/: P256-cortex-m0-ecdh-keil.s
  group vendormodel
    ../../../components/ethermind/mesh/export/vendormodel/server/: vendormodel_server.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
