# Keil uVision project simpleBlePeripheral.uvprojx, settings and files
target SBP Sample (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simpleBlePeripheral
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/simpleBlePeripheral.axf
  AfterMake: fromelf.exe .\Objects\simpleBlePeripheral.axf --i32combined --output .\bin\simpleBlePeripheral.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_QFN32  DEBUG_INFO=3 DBG_RTC_TEST=0  SYS_CLK_TEST_UCDS=0x0004 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\ble\include;..\..\..\components\inc;..\..\..\components\ble\controller\include;..\..\..\components\ble\hci;..\..\..\components\osal\include;..\..\..\components\inc;..\..\..\components\common;..\..\..\components\ble\host;..\..\..\components\profiles\Roles;..\..\..\components\driver\uart;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\SimpleProfile;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\adc;..\..\..\components\driver\kscan;..\..\..\components\driver\flash;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\timer;..\..\..\components\driver\watchdog;..\..\..\components\driver\kscan;..\..\..\lib;..\..\..\components\libraries\cliface
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\rom1Sym.txt --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../../components/profiles/Keys/: simplekeys.c
    ../../../components/profiles/GATT/: gattservapp.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: SimpleBLEPeripheral_Main.c OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c sbpProfile_ota.c
  group rf
    ../../../lib/: rf.lib
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/common/: common.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/spi/: spi.c
    ../../../components/driver/timer/: ap_timer.c
    ../../../components/driver/watchdog/: watchdog.c
  group ancs
    ../../../components/osal/snv/: osal_snv.c
  group components
    ../../../components/libraries/cliface/: cliface.c cli_ble.c
    ../../../components/profiles/Roles/: central.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
