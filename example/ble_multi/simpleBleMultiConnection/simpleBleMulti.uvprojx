# Keil uVision project simpleBleMulti.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simpleBleMulti
  AfterMake: fromelf.exe --bin -o  ./simpleBleMulti.bin  ./Objects/simpleBleMulti.axf
  AfterMake: fromelf.exe .\Objects\simpleBleMulti.axf --i32combined --output .\bin\simpleBleMulti.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_FLASH=512 USE_FCT=0 CFG_OTA_BANK_MODE=OTA_SINGLE_BANK ON_SLB_BOOTLOADER=1  OSAL_CBTIMER_NUM_TASKS=2  HCI_TL_NONE=1  APP_CFG=5 DEBUG_INFO=2  DBG_ROM_MAIN=1 OSALMEM_METRICS=0  CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP MULTI_DEBUG
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0xc
  c include: ..\..\..\components\inc;..\..\..\lib\multi_include;..\..\..\components\ble\hci;..\..\..\components\osal\include;..\..\..\components\inc;..\..\..\components\common;..\..\..\components\ble\host;..\..\..\components\profiles\Roles;..\..\..\components\driver\uart;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\SimpleProfile;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\adc;..\..\..\components\driver\kscan;..\..\..\components\driver\flash;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\i2s;..\..\..\components\driver\timer;..\..\..\components\driver\watchdog;..\..\..\components\driver\kscan;..\..\..\lib;.\source\multi_role;..\..\..\components\libraries\slb;..\..\..\components\libraries\crc16;..\..\..\components\profiles\ota;..\..\..\components\profiles\ota;..\..\..\components\profiles\ota_app;..\..\..\components\profiles\ppsp;..\..\..\components\libraries\tinycrypt-0.2.8\lib\include;..\..\..\components\libraries\cliface
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
    ../../../lib/: multi_stack_lib.lib multi_rf.lib
  group driver
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/timer/: ap_timer.c
    ../../../components/driver/adc/: adc.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/common/: common.c
  group profile
    ./source/multi_role/: multiRole_gap.c multiRoleProfile.c gapbondmgr.c gapgattserver.c gattservapp.c devinfoservice.c battservice.c hiddev.c hidkbdservice.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./source/multi_role/: multi.c multi_role.c multi_role_Main.c OSAL_multi_role.c ppsp_impl.c ppsp_serv.c
    ../../../components/profiles/ppsp/: core_queu.c list_slst.c
  group ancs
    ../../../components/osal/snv/: osal_snv.c
  group TinyCryp
    ../../../components/libraries/tinycrypt-0.2.8/lib/source/: aes_decrypt.c aes_encrypt.c ecc.c hmac.c sha256.c utils.c
  group components
    ../../../components/libraries/cliface/: cli_ble.c cliface.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
